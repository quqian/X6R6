# Keil uVision project x6_boot.uvproj, settings and files
target X6_Boot (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: X6_BOOT +hex
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: HT501x
  c include: .\Main;.\Libraries\CMSIS\DeviceSupport;.\Libraries\CMSIS\CoreSupport;.\Libraries\Startup;.\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fff
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main
    ./Main/: main.c update.c ht60xx_it.c CpuCfg.c include.h CpuCfg.h
  group Driver
    ./Driver/: cmu.c systick.c flash.c
  group CMSIS
    ./Libraries/CMSIS/CoreSupport/: core_cm0.c
    ./Libraries/CMSIS/DeviceSupport/: system_ht6xxx.c
  group Startup
    ./Libraries/Startup/: startup_ht502x.s
