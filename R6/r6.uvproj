# Keil uVision project r6.uvproj, settings and files
target r6 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: r6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: HT6x2x
  c include: .\Main;.\Libraries\CMSIS\DeviceSupport;.\Libraries\CMSIS\CoreSupport;.\Libraries\Startup;.\freertos\include;.\freertos\portable\Keil\ARM_CM0;.\freertos\portable\MemMang;.\freertos\portable\RVDS;.\Driver;.\App
  library: MicroLIB
  memory RVCT4: ROM 0x2000 size 0x1b800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main
    ./Main/: main.c CpuCfg.c CpuCfg.h
  group App
    ./App/: sim800c.c proto.c server.c x6proc.c blue.c ME3612.c ME3630.c spi_w25qx.c ME3610.c
  group Driver
    ./Driver/: cmu.c FIFO.c gpio.c systick.c usart.c flash.c rtc.c ntcad.c led.c bluetooth.c spi.c
  group CMSIS
    ./Libraries/CMSIS/CoreSupport/: core_cm0.c
    ./Libraries/CMSIS/DeviceSupport/: system_ht6xxx.c
  group Startup
    ./Libraries/Startup/: startup_ht6x2x.s
    ./freertos/portable/Keil/ARM_CM0/: port.c
  group FreeRTOS
    ./freertos/portable/MemMang/: heap_4.c
    ./freertos/: list.c queue.c tasks.c
